# Keil uVision project Project.uvprojx, settings and files
target STM32091C_EVAL (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F091VC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32091C_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F091xC,USE_HAL_DRIVER,USE_STM32091C_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32091C_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\CPU;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Middlewares\ST\STemWin\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/Components/spfd5408
    ../../../../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_spi_ex.c
  group Middlewares/STemWin/OS
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Middlewares/STemWin/Config
    ../Src/: GUIConf_stm32091c_eval.c LCDConf_stm32091c_eval.c
  group Drivers/BSP/STM32091C_EVAL
    ../../../../../../Drivers/BSP/STM32091C_EVAL/: stm32091c_eval.c
  group Drivers/BSP/Components/hx8347d
    ../../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
  group Application/User
    ../Src/: main.c stm32f0xx_it.c BASIC_HelloWorld.c
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin532_CM0_Keil.lib
  group Application/MDK-ARM
    ./: startup_stm32f091xc.s
software components: CMSIS:CORE 4.1.0
