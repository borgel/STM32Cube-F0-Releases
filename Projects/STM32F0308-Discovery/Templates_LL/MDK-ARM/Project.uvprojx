# Keil uVision project Project.uvprojx, settings and files
target STM32F0308-Discovery (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F0308-Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030x8,USE_STM320308_DISCO,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../Drivers/STM32F0xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Drivers/STM32F0xx_LL_Driver
    ../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_usart.c stm32f0xx_ll_crs.c stm32f0xx_ll_dma.c stm32f0xx_ll_rcc.c stm32f0xx_ll_exti.c stm32f0xx_ll_crc.c stm32f0xx_ll_i2c.c stm32f0xx_ll_pwr.c stm32f0xx_ll_adc.c stm32f0xx_ll_dac.c stm32f0xx_ll_gpio.c stm32f0xx_ll_spi.c stm32f0xx_ll_tim.c stm32f0xx_ll_utils.c stm32f0xx_ll_rtc.c stm32f0xx_ll_comp.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Example/User
    ../Src/: stm32f0xx_it.c main.c
  group Example/MDK-ARM
    ./: startup_stm32f030x8.s
software components: CMSIS:CORE 4.3.0
